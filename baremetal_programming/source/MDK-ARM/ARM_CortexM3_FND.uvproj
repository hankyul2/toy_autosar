# Keil uVision project ARM_CortexM3_FND.uvproj, settings and files
target ARM_CortexM3_NXP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: FND +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\INC\NXP\LPC17xx;..\Inc;..\..\Huins_NXP_LPC1768_Library\Core\Device\NXP\LPC17xx\Include;..\..\Huins_NXP_LPC1768_Library\Drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: system_LPC17xx.c startup_LPC17xx.s
  group Drivers
    ../../Huins_NXP_LPC1768_Library/Drivers/source/: lpc17xx_gpio.c lpc17xx_pinsel.c LPC1768_utility.c LPC1768_fnd.c lpc17xx_timer.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c lpc17xx_exti.c debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_gpdma.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_iap.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_uart.c lpc17xx_wdt.c LPC1768_motor.c
  group Source Code
    ../Src/: FND.c
    ./: test.c
  group Readme
    ../: Example Manual.txt
